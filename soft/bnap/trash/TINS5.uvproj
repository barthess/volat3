# Keil uVision project TINS5.uvproj, settings and files
target TINS4 (ARM-ADS)
  device: AT91SAM7A3 Atmel
  cpu: IRAM(0x200000-0x207FFF) IROM(0x100000-0x13FFFF) CLOCK(40000000) CPUTYPE(ARM7TDMI)
  output: TINS5 +hex
  c flags: Optim=1 wLevel=2
  c include: ..\;.\at91lib\peripherals;.\at91lib\utility;.\at91lib
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x8000
  group at91lib
    ./at91lib/peripherals/aic/: aic.c
    ./at91lib/peripherals/pio/: pio.c
  group Config
    ./: SAM7.s RTX_Config.c board.h SysConfig.h
  group Source
    ./: CRC8.cpp dc.cpp errorhandler.cpp flash.cpp flash_ram.cpp flashbuf.cpp gps.cpp gsm.cpp lcd.cpp linkpc.cpp main.cpp management.cpp menu.cpp mmc_spi.cpp msg.cpp parameters.cpp retarget.c rtc1338.cpp statehandler.cpp tcpbuf.cpp terminal.cpp twi.cpp usart.cpp usart0.cpp usart1.cpp usart2.cpp uartD.cpp Изменения.txt Arhiv.txt profiler.cpp
  group USB
    ./at91lib/peripherals/USB/: usbuser.c hiduser.c usbcore.c usbdesc.c usbhw.c
